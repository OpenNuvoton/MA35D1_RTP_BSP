# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  group System
    ../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group Demo Files
    ../: main.c
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c PollQ.c semtest.c BlockQ.c dynamic.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c
