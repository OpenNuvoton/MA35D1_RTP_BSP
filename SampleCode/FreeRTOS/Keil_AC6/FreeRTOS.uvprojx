# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (6220000::V6.22::ARMCLANG)
  device: MA35D1_RTP Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x00000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\GCC\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT9: RAM 0x0 size 0x20000
  group System
    ../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group Demo Files
    ../: main.c
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c PollQ.c semtest.c BlockQ.c dynamic.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c
