# IAR project Share_memory_sdram.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NO_ATOMIC_64_SUPPORT; CORE_CM4; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY
  ICCARM.PreInclude: ..\..\..\..\ThirdParty\AMP\libmetal\lib\include\metal\compiler\iar\errno.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include; ..\..\..\..\Library\StdDriver\inc; ..\porting; RTE; ..\..\..\..\ThirdParty\AMP\open-amp\lib\include; ..\..\..\..\ThirdParty\AMP\libmetal\lib\include; ..\..\..\..\ThirdParty\AMP\virtual_driver; ..\..\..\..\ThirdParty\AMP\open-amp\lib\include\openamp
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: share_memory_sdram.bin
  ILINK.IlinkOutputFile: share_memory_sdram.out
  ILINK.IlinkIcfFile: ..\..\..\..\Script\ma35d1_rtp.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group AMP
    ../../../../ThirdParty/AMP/libmetal/lib/system/generic/: condition.c device.c init.c io.c shmem.c
    ../../../../ThirdParty/AMP/libmetal/lib/: device_.c init_.c io_.c log_.c shmem_.c
    ../../../../ThirdParty/AMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ../../../../ThirdParty/AMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../ThirdParty/AMP/libmetal/lib/system/generic/cortexm/: sys_.c
    ../../../../ThirdParty/AMP/open-amp/lib/virtio/: virtio.c virtqueue.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/IAR/: startup_ma35d1_rtp.s
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c whc.c
  group User
    ../: main.c
    ../porting/: mbox_whc.c openamp.c rsc_table.c
