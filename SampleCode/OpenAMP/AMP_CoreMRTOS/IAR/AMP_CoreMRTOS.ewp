# IAR project AMP_CoreMRTOS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa39,Pe111,Pe128,Pe177,Pe185,Pe550,Pe2687
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\ThirdParty\AMP\openamp-1.5.0\libmetal-freertos; ..\..\..\..\ThirdParty\AMP\openamp-1.5.0\include; ..\port; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: AMP_CoreMRTOS.bin
  ILINK.IlinkOutputFile: AMP_CoreMRTOS.out
  ILINK.IlinkIcfFile: ..\..\..\..\Script\ma35d1_rtp.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group AMP/libmetal
    ../../../../ThirdParty/AMP/openamp-1.5.0/libmetal-freertos/metal/: device.c dma.c init.c io.c irq.c log.c shmem.c softirq.c version.c
  group AMP/metal
    ../../../../ThirdParty/AMP/openamp-1.5.0/libmetal-freertos/metal/system/freertos/: condition.c device.c init.c io.c irq.c shmem.c time.c
    ../../../../ThirdParty/AMP/openamp-1.5.0/libmetal-freertos/metal/system/freertos/cm4/: sys.c
  group AMP/openamp
    ../../../../ThirdParty/AMP/openamp-1.5.0/remoteproc/: elf_loader.c remoteproc.c remoteproc_virtio.c rsc_table_parser.c
    ../../../../ThirdParty/AMP/openamp-1.5.0/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../ThirdParty/AMP/openamp-1.5.0/virtio/: virtio.c virtqueue.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/IAR/: startup_ma35d1_rtp.s
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../port/: cm4_rproc.c platform_info.c rsc_table.c
    ../: crc_table.c main.c
