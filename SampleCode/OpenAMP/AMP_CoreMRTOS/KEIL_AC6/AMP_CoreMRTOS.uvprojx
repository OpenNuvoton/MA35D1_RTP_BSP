# Keil uVision project AMP_CoreMRTOS.uvprojx, settings and files
target AMP_CoreMRTOS (6120000::V6.12::.\ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: AMP_CoreMRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\..\..\ThirdParty\AMP\openamp-1.5.0\libmetal-freertos;..\..\..\..\ThirdParty\AMP\openamp-1.5.0\include;..\port;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group System
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group lib
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group metal
    ../../../../ThirdParty/AMP/openamp-1.5.0/libmetal-freertos/metal/system/freertos/cm4/: sys.c
    ../../../../ThirdParty/AMP/openamp-1.5.0/libmetal-freertos/metal/system/freertos/: condition.c device.c init.c io.c irq.c shmem.c time.c
  group libmetal
    ../../../../ThirdParty/AMP/openamp-1.5.0/libmetal-freertos/metal/: device.c init.c irq.c log.c shmem.c version.c dma.c io.c softirq.c
  group openamp
    ../../../../ThirdParty/AMP/openamp-1.5.0/remoteproc/: elf_loader.c remoteproc.c remoteproc_virtio.c rsc_table_parser.c
    ../../../../ThirdParty/AMP/openamp-1.5.0/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../ThirdParty/AMP/openamp-1.5.0/virtio/: virtio.c virtqueue.c
  group port
    ../port/: cm4_rproc.c platform_info.c rsc_table.c
  group User
    ../: crc_table.c main.c
software components: CMSIS:CORE 6.1.0
