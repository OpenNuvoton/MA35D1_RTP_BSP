# Keil uVision project share_memory_sram_v2.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: share_memory_sram_v2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NO_ATOMIC_64_SUPPORT METAL_INTERNAL METAL_MAX_DEVICE_REGIONS=2  VIRTIO_SLAVE_ONLY
  c misc: --diag_suppress=1254,111
  c include: ..\..\..\..\ThirdParty\AMP\open-amp\lib\include\openamp;..\..\..\..\ThirdParty\AMP\open-amp\lib\include;..\..\..\..\ThirdParty\AMP\libmetal\lib\include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\porting;.\RTE
  link misc: --map --first='startup_ma35d1_rtp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group User
    ../: main.c
    ../porting/: mbox_whc.c openamp.c rsc_table.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c whc.c uart.c retarget.c
  group AMP
    ../../../../ThirdParty/AMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ../../../../ThirdParty/AMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../../../../ThirdParty/AMP/open-amp/lib/virtio/: virtio.c virtqueue.c
    ../../../../ThirdParty/AMP/libmetal/lib/: device_.c init_.c io_.c shmem_.c log_.c
    ../../../../ThirdParty/AMP/libmetal/lib/system/generic/: device.c init.c io.c shmem.c time.c
    ../../../../ThirdParty/AMP/libmetal/lib/system/generic/cortexm/: sys_.c
