# IAR project RTC_Time_Display.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include; ..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTC_Time_Display.bin
  ILINK.IlinkOutputFile: RTC_Time_Display.out
  ILINK.IlinkIcfFile: ..\..\..\..\Script\ma35d1_rtp.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/IAR/: startup_ma35d1_rtp.s
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c rtc.c sys.c uart.c
  group User
    ../: main.c
