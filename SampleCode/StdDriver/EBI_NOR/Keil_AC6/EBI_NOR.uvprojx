# Keil uVision project EBI_NOR.uvprojx, settings and files
target EBI_NOR (6120000::V6.12::.\ARMCLANG)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: EBI_NOR
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_ma35d1_rtp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group User
    ../: main.c nor_MX29LV320T.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c ebi.c
