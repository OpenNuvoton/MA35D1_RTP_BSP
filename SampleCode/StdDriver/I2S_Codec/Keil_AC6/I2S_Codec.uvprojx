# Keil uVision project I2S_Codec.uvprojx, settings and files
target I2S_Codec (6220000::V6.22::ARMCLANG)
  device: MA35D1_RTP Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x00000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000)
  output: I2S_Codec
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT9: RAM 0x0 size 0x20000
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group Source
    ../: main.c isr.c
  group Library
    ../../../../Library/StdDriver/src/: i2s.c i2c.c clk.c sys.c uart.c gpio.c retarget.c
