<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\KPI.ewp</path>
    </project>
    <batchBuild />
</workspace>
