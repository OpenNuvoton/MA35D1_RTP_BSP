# Keil uVision project PDMA_ScatterGather_PingPongBuffer.uvprojx, settings and files
target PDMA_ScatterGather_PingPongBuffer (6220000::V6.22::ARMCLANG)
  device: MA35D16A887C Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x00000000,0x20000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000)
  output: PDMA_ScatterGather_PingPongBuffer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include
  library: MicroLIB
  memory RVCT9: RAM 0x0 size 0x20000
  link misc: --map --first='startup_ma35d1_rtp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c pdma.c retarget.c uart.c
