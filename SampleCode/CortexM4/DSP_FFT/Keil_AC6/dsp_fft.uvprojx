# Keil uVision project dsp_fft.uvprojx, settings and files
target dsp_fft (6150000::V6.15::ARMCLANG)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: dsp_fft
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4=1, __FPU_PRESENT=1UL
  c include: ..\..\..\..\Library\Device\Nuvoton\ma35d1_rtp\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_ma35d1_rtp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/: system_ma35d1_rtp.c
    ../../../../Library/Device/Nuvoton/ma35d1_rtp/Source/ARM/: startup_ma35d1_rtp.s
  group User
    ../: main.c arm_fft_bin_data.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
